options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: wifi_transceiver
    output_language: python
  states: {}

blocks:
- name: chan_est
  id: variable_qtgui_chooser
  parameters:
    labels: '["LS", "LMS", "STA", "Linear Comb"]'
    num_opts: '0'
    options: '[ieee802_11.LS, ieee802_11.LMS, ieee802_11.STA, ieee802_11.COMB]'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {state: disabled}
- name: chan_est
  id: variable
  parameters:
    value: '0'
  states: {}
- name: encoding
  id: variable_qtgui_chooser
  parameters:
    labels: '["BPSK 1/2", "BPSK 3/4", "QPSK 1/2", "QPSK 3/4", "16QAM 1/2", "16QAM 3/4", "64QAM 2/3", "64QAM 3/4"]'
    num_opts: '0'
    options: '[0, 1, 2, 3, 4, 5, 6, 7]'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {state: disabled}
- name: freq
  id: variable_qtgui_chooser
  parameters:
    labels: '[''  1 | 2412.0 | 11g'', ''  2 | 2417.0 | 11g'', ''  3 | 2422.0 | 11g'', ''  4 | 2427.0 | 11g'', ''  5 | 2432.0 | 11g'', ''  6 | 2437.0 | 11g'', ''  7 | 2442.0 | 11g'', ''  8 | 2447.0 | 11g'', ''  9 | 2452.0 | 11g'', '' 10 | 2457.0 | 11g'', '' 11 | 2462.0 | 11g'', '' 12 | 2467.0 | 11g'', '' 13 | 2472.0 | 11g'', '' 14 | 2484.0 | 11g'', '' 34 | 5170.0 | 11a'', '' 36 | 5180.0 | 11a'', '' 38 | 5190.0 | 11a'', '' 40 | 5200.0 | 11a'', '' 42 | 5210.0 | 11a'', '' 44 | 5220.0 | 11a'', '' 46 | 5230.0 | 11a'', '' 48 | 5240.0 | 11a'', '' 50 | 5250.0 | 11a'', '' 52 | 5260.0 | 11a'', '' 54 | 5270.0 | 11a'', '' 56 | 5280.0 | 11a'', '' 58 | 5290.0 | 11a'', '' 60 | 5300.0 | 11a'', '' 62 | 5310.0 | 11a'', '' 64 | 5320.0 | 11a'', ''100 | 5500.0 | 11a'', ''102 | 5510.0 | 11a'', ''104 | 5520.0 | 11a'', ''106 | 5530.0 | 11a'', ''108 | 5540.0 | 11a'', ''110 | 5550.0 | 11a'', ''112 | 5560.0 | 11a'', ''114 | 5570.0 | 11a'', ''116 | 5580.0 | 11a'', ''118 | 5590.0 | 11a'', ''120 | 5600.0 | 11a'', ''122 | 5610.0 | 11a'', ''124 | 5620.0 | 11a'', ''126 | 5630.0 | 11a'', ''128 | 5640.0 | 11a'', ''132 | 5660.0 | 11a'', ''134 | 5670.0 | 11a'', ''136 | 5680.0 | 11a'', ''138 | 5690.0 | 11a'', ''140 | 5700.0 | 11a'', ''142 | 5710.0 | 11a'', ''144 | 5720.0 | 11a'', ''149 | 5745.0 | 11a (SRD)'', ''151 | 5755.0 | 11a (SRD)'', ''153 | 5765.0 | 11a (SRD)'', ''155 | 5775.0 | 11a (SRD)'', ''157 | 5785.0 | 11a (SRD)'', ''159 | 5795.0 | 11a (SRD)'', ''161 | 5805.0 | 11a (SRD)'', ''165 | 5825.0 | 11a (SRD)'', ''172 | 5860.0 | 11p'', ''174 | 5870.0 | 11p'', ''176 | 5880.0 | 11p'', ''178 | 5890.0 | 11p'', ''180 | 5900.0 | 11p'', ''182 | 5910.0 | 11p'', ''184 | 5920.0 | 11p'']'
    num_opts: '0'
    options: '[2412000000.0, 2417000000.0, 2422000000.0, 2427000000.0, 2432000000.0, 2437000000.0, 2442000000.0, 2447000000.0, 2452000000.0, 2457000000.0, 2462000000.0, 2467000000.0, 2472000000.0, 2484000000.0, 5170000000.0, 5180000000.0, 5190000000.0, 5200000000.0, 5210000000.0, 5220000000.0, 5230000000.0, 5240000000.0, 5250000000.0, 5260000000.0, 5270000000.0, 5280000000.0, 5290000000.0, 5300000000.0, 5310000000.0, 5320000000.0, 5500000000.0, 5510000000.0, 5520000000.0, 5530000000.0, 5540000000.0, 5550000000.0, 5560000000.0, 5570000000.0, 5580000000.0, 5590000000.0, 5600000000.0, 5610000000.0, 5620000000.0, 5630000000.0, 5640000000.0, 5660000000.0, 5670000000.0, 5680000000.0, 5690000000.0, 5700000000.0, 5710000000.0, 5720000000.0, 5745000000.0, 5755000000.0, 5765000000.0, 5775000000.0, 5785000000.0, 5795000000.0, 5805000000.0, 5825000000.0, 5860000000.0, 5870000000.0, 5880000000.0, 5890000000.0, 5900000000.0, 5910000000.0, 5920000000.0]'
    type: real
    value: '5890000000'
  states: {state: disabled}
- name: lo_offset
  id: variable
  parameters:
    value: '0'
  states: {}
- name: lo_offset
  id: variable_qtgui_chooser
  parameters:
    num_opts: '3'
    option1: 6e6
    option2: 11e6
    type: real
    value: '0'
  states: {state: disabled}
- name: pad_front
  id: parameter
  parameters:
    type: intx
    value: '10000'
  states: {}
- name: pad_tail
  id: parameter
  parameters:
    type: intx
    value: '10000'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.75'
  states: {state: disabled}
- name: samp_rate
  id: variable_qtgui_chooser
  parameters:
    labels: '["5 MHz", "10 MHz", "20 MHz"]'
    num_opts: '0'
    options: '[5e6, 10e6, 20e6]'
    type: real
    value: 10e6
  states: {state: disabled}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.75'
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: /tmp/wifi.pcap
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.6'
    minoutbuf: '100000'
    type: complex
  states: {}
- name: blocks_pdu_to_tagged_stream_0_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: complex
  states: {state: disabled}
- name: blocks_tuntap_pdu_0
  id: blocks_tuntap_pdu
  parameters:
    ifn: tap0
    istunflag: 'False'
    mtu: '440'
  states: {}
- name: encoding
  id: parameter
  parameters:
    type: intx
    value: '0'
  states: {}
- name: foo_packet_pad2_0
  id: foo_packet_pad2
  parameters:
    debug: 'False'
    delay: 'False'
    delay_sec: '0.001'
    minoutbuf: '100000'
    pad_front: pad_front
    pad_tail: pad_tail
  states: {}
- name: foo_wireshark_connector_0
  id: foo_wireshark_connector
  parameters:
    debug: 'False'
    tech: '127'
  states: {}
- name: freq
  id: parameter
  parameters:
    type: eng_float
    value: '5890000000'
  states: {}
- name: ieee802_11_ether_encap_0
  id: ieee802_11_ether_encap
  parameters:
    debug: 'False'
  states: {}
- name: ieee802_11_mac_0
  id: ieee802_11_mac
  parameters:
    bss_mac: '[0x42, 0x42, 0x42, 0x42, 0x42, 0x42]'
    dst_mac: '[]'
    src_mac: '[]'
  states: {}
- name: ieee802_11_parse_mac_0
  id: ieee802_11_parse_mac
  parameters:
    debug: 'False'
    log: 'False'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: 48*10
    type: complex
  states: {state: disabled}
- name: rx_gain
  id: parameter
  parameters:
    type: intx
    value: '40'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    type: eng_float
    value: 10e6
  states: {}
- name: tx_gain
  id: parameter
  parameters:
    type: intx
    value: '62'
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      gr.prefs().singleton().set_bool("ControlPort", "on", True)
      gr.prefs().singleton().set_bool("PerfCounters", "on", True)
      gr.prefs().singleton().set_bool("PerfCounters", "export", True)
    section: main_after_init
  states: {}
- name: snippet_1
  id: snippet
  parameters:
    code: |-
      import re
      interval=0.1
      ep = gr.rpcmanager_get().endpoints()[0]
      hostname = re.search(r"-h (\S+|\d+\.\d+\.\d+\.\d+)", ep).group(1)
      portnum = re.search(r"-p (\d+)", ep).group(1)
      print("Hostname:", hostname)
      print("Port:", portnum)

      f = open("/tmp/802_bsr.csv", 'w')
      f.write("time,buffer_state\n")

      def bsr_thread(f, interval):
      	from gnuradio.ctrlport.GNURadioControlPortClient import GNURadioControlPortClient
      	radiosys = GNURadioControlPortClient(hostname, portnum)
      	radio = radiosys.client

      	t=0
      	while not stop_module.stop_flag.is_set():
      		f.write(str(round(t,2))+","+str(radio.getKnobs(['ofdm_cyclic_prefixer0::input % full'])['ofdm_cyclic_prefixer0::input % full'].value[0])+"\n")
      		f.flush()
      		t += interval
      		time.sleep(interval)
      	f.close()

      import threading
      th = threading.Thread(target=bsr_thread, args=(f, interval))
      th.start()
    section: main_after_start
  states: {}
- name: snippet_2
  id: snippet
  parameters:
    code: stop_module.stop_flag.set()
    section: main_after_stop
  states: {}
- name: stop_module
  id: epy_module
  parameters:
    source_code: |
      import threading
      stop_flag = threading.Event()
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: uhd.tune_request(freq, rf_freq = freq - lo_offset, rf_freq_policy=uhd.tune_request.POLICY_MANUAL)
    clock_rate: '0.0'
    dev_addr: usrp_addr
    dev_args: '""'
    gain0: tx_gain
    len_tag_name: packet_len
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    center_freq0: uhd.tune_request(freq, rf_freq = freq - lo_offset, rf_freq_policy=uhd.tune_request.POLICY_MANUAL)
    clock_rate: '0.0'
    dc_offs_enb0: '""'
    dev_addr: usrp_addr
    dev_args: '""'
    gain0: rx_gain
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: usrp_addr
  id: parameter
  parameters:
    label: USRP address
    type: str
    value: '""'
  states: {}
- name: wifi_phy_hier_0
  id: wifi_phy_hier
  parameters:
    bandwidth: samp_rate
    chan_est: chan_est
    encoding: encoding
    frequency: freq
    sensitivity: '0.56'
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: 0.0.0.0
    port: '8086'
  states: {}

connections:
- [blocks_multiply_const_vxx_0, '0', foo_packet_pad2_0, '0']
- [blocks_pdu_to_tagged_stream_0_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_tuntap_pdu_0, pdus, ieee802_11_ether_encap_0, from tap]
- [foo_packet_pad2_0, '0', uhd_usrp_sink_0, '0']
- [foo_wireshark_connector_0, '0', blocks_file_sink_0, '0']
- [ieee802_11_ether_encap_0, to tap, blocks_tuntap_pdu_0, pdus]
- [ieee802_11_ether_encap_0, to wifi, ieee802_11_mac_0, app in]
- [ieee802_11_mac_0, phy out, wifi_phy_hier_0, mac_in]
- [uhd_usrp_source_0, '0', wifi_phy_hier_0, '0']
- [wifi_phy_hier_0, '0', blocks_multiply_const_vxx_0, '0']
- [wifi_phy_hier_0, carrier, blocks_pdu_to_tagged_stream_0_0, pdus]
- [wifi_phy_hier_0, mac_out, foo_wireshark_connector_0, in]
- [wifi_phy_hier_0, mac_out, ieee802_11_ether_encap_0, from wifi]
- [wifi_phy_hier_0, mac_out, ieee802_11_mac_0, phy in]
- [wifi_phy_hier_0, mac_out, ieee802_11_parse_mac_0, in]

metadata:
  file_format: 1
